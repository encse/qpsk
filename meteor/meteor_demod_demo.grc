options:
  parameters:
    author: HA7NCS
    comment: |-
      Meteor M-N2 LRPT (72k) QPSK demodulator.

      Accepts complex float32 (cf32) IQ input, with e.g. nominal sample rate 256 kHz
      (adjustable). Demonstrates the complete LRPT demodulation pipeline using
      gr-satellites blocks together with custom GRC blocks.
    copyright: Copyright (c) 2026 David Nemeth-Csoka
    description: Meteor M-N2 LRPT (72k) QPSK demodulator.
    generate_options: qt_gui
    id: meteor_demod
    output_language: python
    title: Meteor M N 2-x ,72k LRPT demodulator
  states: {}

blocks:
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/encse/projects/qpsk/2026-02-13_07-39-09_256000SPS_137900000Hz.cf32
    repeat: 'False'
    type: complex
  states: {}
- name: ccsds_image_decoder_0
  id: ccsds_image_decoder
  parameters: {}
  states: {}
- name: ccsds_image_viewer_0
  id: ccsds_image_viewer
  parameters:
    gui_hint: 0,1,4,1
    width: '1568'
  states: {}
- name: meteor_lrpt_0
  id: meteor_lrpt
  parameters:
    sample_rate: '256000'
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    axislabels: 'False'
    color1: '"red"'
    gui_hint: 0,0,2,1
    legend: 'False'
    name: Constellation
    size: '4000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '256000'
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,1
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 2,0,1,1
    label1: BER
    min: '0'
    name: ''
    type: float
  states: {}

connections:
- [blocks_file_source_0, '0', meteor_lrpt_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [ccsds_image_decoder_0, out, ccsds_image_viewer_0, in]
- [meteor_lrpt_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [meteor_lrpt_0, '1', qtgui_number_sink_0, '0']
- [meteor_lrpt_0, msu_mr_1, ccsds_image_decoder_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
