options:
  parameters:
    category: '[Meteor]'
    generate_options: hb
    id: ccsds_channel_decoder
    output_language: python
    title: CCSDS Channel Decoder
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: cadu_framer_0
  id: cadu_framer
  parameters:
    cadu_asm: '0x1ACFFC1D'
    cadu_len_bytes: '1020'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: BER
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: cadus
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: soft_symbols
    type: float
  states: {}
- name: satellites_ccsds_descrambler_0
  id: satellites_ccsds_descrambler
  parameters: {}
  states: {}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    interleave: '4'
  states: {}
- name: viterbi_0
  id: viterbi
  parameters:
    code: '"NASA-DSN uninverted"'
  states: {}

connections:
- [cadu_framer_0, cadu, satellites_ccsds_descrambler_0, in]
- [digital_diff_decoder_bb_0, '0', cadu_framer_0, '0']
- [pad_source_0, '0', viterbi_0, '0']
- [satellites_ccsds_descrambler_0, out, satellites_decode_rs_ccsds_0, in]
- [satellites_decode_rs_ccsds_0, out, pad_sink_1, in]
- [viterbi_0, '0', digital_diff_decoder_bb_0, '0']
- [viterbi_0, '1', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
