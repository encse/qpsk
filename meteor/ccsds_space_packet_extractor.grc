options:
  parameters:
    category: '[Meteor]'
    generate_options: hb
    id: ccsds_space_packet_extractor
    output_language: python
    title: CCSDS Space Packet Extractor
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: space_packets
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: cadus
    type: message
  states: {}
- name: space_packet_assembler_0
  id: space_packet_assembler
  parameters: {}
  states: {}
- name: vcdu_parser_0
  id: vcdu_parser
  parameters: {}
  states: {}

connections:
- [pad_source_0, out, vcdu_parser_0, in]
- [space_packet_assembler_0, out, pad_sink_0, in]
- [vcdu_parser_0, out, space_packet_assembler_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
