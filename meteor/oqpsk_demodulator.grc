options:
  parameters:
    category: '[Meteor]'
    comment: Parameters copied from Satdump
    generate_options: hb
    id: oqpsk_demodulator
    output_language: python
    title: OQPSK Demodulator
  states: {}

blocks:
- name: pipeline_sample_rate
  id: variable
  parameters:
    value: '144000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '72000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: sps // 2
    type: float
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.0087'
    gain_omega: 0.25 * 0.0087 * 0.0087
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.002'
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(1.0, pipeline_sample_rate, sym_rate, alpha=0.5, ntaps=31)
    type: ccc
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: constellation
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: soft_symbols
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: sample_rate
    interp: pipeline_sample_rate
    type: ccc
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: frequency_synced
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: frequency_synced
  states: {}

connections:
- [analog_agc2_xx_0, '0', fir_filter_xxx_1, '0']
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_complex_to_float_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_0, '0']
- [blocks_delay_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_float_to_complex_0_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_interleave_0, '0', pad_sink_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_complex_to_float_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', pad_sink_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_0, '0']
- [fir_filter_xxx_1, '0', digital_costas_loop_cc_0, '0']
- [pad_source_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc2_xx_0, '0']
- [virtual_source_0, '0', blocks_complex_to_float_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
