options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: pll_loop_bw
  id: variable
  parameters:
    value: '0.002'
  states: {}
- name: rrc_alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: '31'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '72000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: sps // 2
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/encse/projects/qpsk/2026-02-13_07-39-09_256000SPS_137900000Hz.cf32
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    comment: swap in0 and in1 to swap IQ stream
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: set to 1, -1, 1j or -1j to rotate / mirror I and Q
    const: '1'
    type: complex
  states: {}
- name: cadu_framer_0
  id: cadu_framer
  parameters:
    cadu_asm: '0x1ACFFC1D'
    cadu_len_bytes: '1020'
  states: {}
- name: ccsds_image_decoder_0
  id: ccsds_image_decoder
  parameters:
    apid: '65'
  states: {}
- name: ccsds_image_viewer_0
  id: ccsds_image_viewer
  parameters:
    gui_hint: 0,1,3,1
    width: '1568'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.0087'
    gain_omega: 0.25 * 0.0087 * 0.0087
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pll_loop_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(1.0, samp_rate, sym_rate, rrc_alpha, rrc_taps)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: viterbi_0
  id: viterbi
  parameters:
    code: '"NASA-DSN uninverted"'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: METEOR M 2-X 72k, oqpsk demodulator and image viewer
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    axislabels: 'False'
    color1: '"red"'
    gui_hint: 0,0,1,1
    legend: 'False'
    name: Constellation
    size: '4000'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 1,0,1,1
    label1: BER
    min: '0'
    name: ''
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      adjust  interpolation and decimation so that 

      the input's sample rate * interpolation / decimation == 72k

      for example

      250m * 5 / 9 = 72k
    decim: '16'
    interp: '9'
    type: ccc
  states: {}
- name: satellites_ccsds_descrambler_0
  id: satellites_ccsds_descrambler
  parameters: {}
  states: {}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    interleave: '4'
  states: {}
- name: space_packet_assembler_0
  id: space_packet_assembler
  parameters: {}
  states: {}
- name: vcdu_parser_0
  id: vcdu_parser
  parameters: {}
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: file_input
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: clock_recovered
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: soft_symbols
  states: {}
- name: virtual_sink_0_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: cadus
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: file_input
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    comment: rotate, swap IQ stream
    stream_id: clock_recovered
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: soft_symbols
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: cadus
  states: {}

connections:
- [analog_agc2_xx_0, '0', virtual_sink_0_1, '0']
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_complex_to_float_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_0, '0']
- [blocks_delay_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_interleave_0, '0', virtual_sink_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_complex_to_float_0, '0']
- [cadu_framer_0, cadu, satellites_ccsds_descrambler_0, in]
- [ccsds_image_decoder_0, out, ccsds_image_viewer_0, in]
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', virtual_sink_0_1_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_float_0_0, '0']
- [digital_diff_decoder_bb_0, '0', cadu_framer_0, '0']
- [fir_filter_xxx_1, '0', digital_costas_loop_cc_0, '0']
- [viterbi_0, '0', digital_diff_decoder_bb_0, '0']
- [viterbi_0, '1', qtgui_number_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc2_xx_0, '0']
- [satellites_ccsds_descrambler_0, out, satellites_decode_rs_ccsds_0, in]
- [satellites_decode_rs_ccsds_0, out, virtual_sink_0_1_0_0_0, '0']
- [space_packet_assembler_0, out, ccsds_image_decoder_0, in]
- [vcdu_parser_0, out, space_packet_assembler_0, in]
- [virtual_source_0, '0', fir_filter_xxx_1, '0']
- [virtual_source_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [virtual_source_0_0_0, '0', viterbi_0, '0']
- [virtual_source_0_0_0_0, '0', vcdu_parser_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
