options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: pll_loop_bw
  id: variable
  parameters:
    value: '0.002'
  states: {}
- name: rrc_alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: '31'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sym_rate * sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '72000'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: sps // 2
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: cadu.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/encse/projects/qpsk/2026-02-13_07-39-09_256000SPS_137900000Hz.cf32
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    log_level: trace
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '30'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: cadu_framer_0
  id: cadu_framer
  parameters:
    cadu_asm: '0x1ACFFC1D'
    cadu_len_bytes: '1020'
  states: {}
- name: ccsds_image_sink_0
  id: ccsds_image_sink
  parameters: {}
  states: {}
- name: ccsds_image_viewer_0
  id: ccsds_image_viewer
  parameters:
    gui_hint: 0,0,1,1
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.0087'
    gain_omega: 0.25 * 0.0087 * 0.0087
    mu: '0.5'
    omega: sps
    omega_relative_limit: '0.005'
    type: complex
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: pll_loop_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(1.0, samp_rate, sym_rate, rrc_alpha, rrc_taps)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio.filter import firdes
  states: {}
- name: my_viterbi_0
  id: my_viterbi
  parameters:
    code: '"NASA-DSN uninverted"'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: pdu_length
    type: byte
  states: {}
- name: qtgui_const_sink_x_0_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,2, 1,1
    name: satdump
    size: '4000'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '0.5'
    ymin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '9'
    type: ccc
  states: {}
- name: satellites_ccsds_descrambler_0
  id: satellites_ccsds_descrambler
  parameters: {}
  states: {}
- name: satellites_ccsds_telemetry_parser_0
  id: satellites_ccsds_telemetry_parser
  parameters: {}
  states: {state: disabled}
- name: satellites_decode_rs_ccsds_0
  id: satellites_decode_rs_ccsds
  parameters:
    basis: 'False'
    interleave: '4'
  states: {}
- name: space_packet_assembler_0
  id: space_packet_assembler
  parameters: {}
  states: {}
- name: take_n_0
  id: take_n
  parameters:
    n: '1'
  states: {state: disabled}
- name: vcdu_parser_0
  id: vcdu_parser
  parameters: {}
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: file_input
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: clock_recovered
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: soft_symbols
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: file_input
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: clock_recovered
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: soft_symbols
  states: {}

connections:
- [analog_agc2_xx_0, '0', virtual_sink_0_1, '0']
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_complex_to_float_0_0, '0', blocks_float_to_complex_0_0, '0']
- [blocks_complex_to_float_0_0, '1', blocks_delay_0_0, '0']
- [blocks_delay_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_interleave_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_complex_to_float_0, '0']
- [cadu_framer_0, cadu, satellites_ccsds_descrambler_0, in]
- [ccsds_image_sink_0, img_out, ccsds_image_viewer_0, in]
- [digital_clock_recovery_mm_xx_0, '0', qtgui_const_sink_x_0_0_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', virtual_sink_0_1_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_float_0_0, '0']
- [digital_diff_decoder_bb_0, '0', cadu_framer_0, '0']
- [fir_filter_xxx_1, '0', digital_costas_loop_cc_0, '0']
- [my_viterbi_0, '0', digital_diff_decoder_bb_0, '0']
- [my_viterbi_0, '1', qtgui_time_sink_x_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc2_xx_0, '0']
- [satellites_ccsds_descrambler_0, out, satellites_decode_rs_ccsds_0, in]
- [satellites_ccsds_telemetry_parser_0, out, take_n_0, in]
- [satellites_decode_rs_ccsds_0, out, vcdu_parser_0, in]
- [space_packet_assembler_0, out, ccsds_image_sink_0, in]
- [take_n_0, out, blocks_message_debug_0, print]
- [vcdu_parser_0, out, pdu_pdu_to_tagged_stream_0, pdus]
- [vcdu_parser_0, out, satellites_ccsds_telemetry_parser_0, in]
- [vcdu_parser_0, out, space_packet_assembler_0, in]
- [virtual_source_0, '0', fir_filter_xxx_1, '0']
- [virtual_source_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [virtual_source_0_0_0, '0', my_viterbi_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
