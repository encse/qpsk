options:
  parameters:
    generate_options: hb
    id: my_viterbi
    max_nouts: '2'
    output_language: python
    title: my_viterbi
  states: {}

blocks:
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: code
  id: parameter
  parameters:
    type: str
    value: '"CCSDS uninverted"'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: ber
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: satellites_ccsds_viterbi_0
  id: satellites_ccsds_viterbi
  parameters: {}
  states: {}

connections:
- [blocks_char_to_float_0, '0', pad_sink_1, '0']
- [pad_source_0, '0', satellites_ccsds_viterbi_0, '0']
- [satellites_ccsds_viterbi_0, '0', blocks_char_to_float_0, '0']
- [satellites_ccsds_viterbi_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
