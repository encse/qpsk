options:
  parameters:
    description: Stream bits (0/1) -> CADU PDUs (u8vector, 1024 bytes)
    generate_options: hb
    id: cadu_framer
    max_nouts: '1'
    output_language: python
    title: cadu_framer
  states: {}

blocks:
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: cadu_framer_0
  id: cadu_framer
  parameters:
    cadu_asm: '0x1ACFFC1D'
    cadu_len_bytes: '1024'
  states: {}
- name: pad_message_source_0
  id: pad_message_source
  parameters:
    label: cadu
    optional: 'False'
  states: {}

connections:
- [pad_source_0, '0', cadu_framer_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
